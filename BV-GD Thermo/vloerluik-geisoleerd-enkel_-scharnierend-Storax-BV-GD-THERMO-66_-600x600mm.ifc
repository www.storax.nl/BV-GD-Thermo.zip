Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 9c5b9cd5-5ea2-4cc6-9004-59667168cfb9.ifc
Time: 2026-08-11T11:47:32
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, scharnierend Storax - BV-GD-THERMO 66, 600x600mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAAKbJcRcFAAAAzeoCAAV2SgAAJVQBAInDAACN7AIATOwCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAKbJcRcFAAAAzeoCAAV2SgAAJVQBAInDAACN7AIATOwCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 32 kg/st; STABU2: 43.31.10; lengte: 752 mm; dagmaatlengte: 600 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 735 mm; Rc-waarde: 4 m²·k/w; type: 66; serie: BV-GD-THERMO; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; dagmaatbreedte: 600 mm; omranding: staal; luik: staal; aandrijving: Storax - gasdrukveer
