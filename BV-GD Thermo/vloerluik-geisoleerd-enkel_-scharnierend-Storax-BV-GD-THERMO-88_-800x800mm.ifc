Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: fbb76d40-c51b-4890-a7f1-35949f381799.ifc
Time: 2026-08-11T11:49:35
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, scharnierend Storax - BV-GD-THERMO 88, 800x800mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAAKZedxcFAAAAzeoCAAV2SgAAJVQBAInDAACN7AIA2-oCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAKZedxcFAAAAzeoCAAV2SgAAJVQBAInDAACN7AIA2-oCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 46 kg/st; STABU2: 43.31.10; lengte: 952 mm; dagmaatlengte: 800 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 935 mm; Rc-waarde: 4 m²·k/w; type: 88; serie: BV-GD-THERMO; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; dagmaatbreedte: 800 mm; omranding: staal; luik: staal; aandrijving: Storax - gasdrukveer
