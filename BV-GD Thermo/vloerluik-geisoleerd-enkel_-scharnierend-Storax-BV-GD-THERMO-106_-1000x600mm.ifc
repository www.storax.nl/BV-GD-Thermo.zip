Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: bb53688d-45ca-4327-b6b5-8eaa3e864b6a.ifc
Time: 2026-08-11T11:50:32
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, scharnierend Storax - BV-GD-THERMO 106, 1000x600mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAAKY5dhcFAAAAzeoCAAV2SgAAJVQBAInDAACN7AIAvOsCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAKY5dhcFAAAAzeoCAAV2SgAAJVQBAInDAACN7AIAvOsCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 46 kg/st; STABU2: 43.31.10; lengte: 1152 mm; dagmaatlengte: 1000 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 735 mm; Rc-waarde: 4 m²·k/w; type: 106; serie: BV-GD-THERMO; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; dagmaatbreedte: 600 mm; omranding: staal; luik: staal; aandrijving: Storax - gasdrukveer
